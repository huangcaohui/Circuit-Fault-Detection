# Keil uVision project Circuit Fault Detection.uvprojx, settings and files
target Circuit Fault Detection (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Circuit Fault Detection +hex
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\AD9910;..\HARDWARE\AD7606;..\USERLIB;..\SYSTEM\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/AD9910/: ad9910.c Square.c
    ../HARDWARE/AD7606/: ad7606.c
  group SYSTEM
    ../SYSTEM/src/: sys.c delay.c pwm.c timer.c usart.c adc.c iwdg.c iic.c spi.c exti.c
  group USERLIB
    ../USERLIB/: fir.c floatfft.c display.c calculation.c fault_detect.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_exti.c
  group README
    ../: readme.txt
